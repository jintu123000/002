# Keil uVision project firmware.uvprojx, settings and files
target STM32F103C8 (5060061::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: firmware +hex
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F103xB
  c include: ..\Inc;..\FreeRTOS\include
  asm include: ..\Inc;..\FreeRTOS\include
  group App
    ../Src/: main.c
  group FreeRTOS
    ../Src/FreeRTOS/: tasks.c list.c queue.c
    ../Src/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group CMSIS
    ../Src/: system_stm32f1xx.c
  group Startup
    ../Src/: startup_stm32f10x_md.s
